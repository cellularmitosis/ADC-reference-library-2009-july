Recent History:
===============

5 Mar 96	Added QuickTime progress proc to the call to FCompressImage() that calls
			the app's progress function to give the user finer control over the 
			UI during processing.
			
			Now deactivating the menu bar during processing.

5 Mar 96	Added alert warning if the PICT does not appear to be oriented correctly.

			Added splash screen and new About Box art.
			
			Created FAT version.
			
			Created new projects for the FAT version, the 68K code for the FAT version,
			the 68K sample code and the PPC sample code.
			
			Create authoring header and used the file format document for structs.

4 Mar 96	Pan and zoom fields now allow decimals but not negative signs.

			Using an improved message for error -620 (not enough physical memory).

3 Mar 96	Improved image size warning alert to include current size.
			
			Now does not close a PICT window if an error occurs.
			
			Fixed problem where LDialogBox and CP2VRWindow were both adding the window
			as a listener.

2 Mar 96	Now using the notification manager to tease the user into switching in
			before showing error alerts (if necessary).

1 Mar 96	Improved compression description text.
			
			Image size warning dialog.

29 Feb 96	Fixed problem with path names when the Set button is used. An extra colon
			was being added.
			
			Created a better key filter for the tilt field in the movie and the preferences
			windows.
			
29 Feb 96	Some more path name string clean-up.
			
			Now quits when in drop mode and odoc events pass a list of files to the app
			once processing is finished.
			
			Added nicer error descriptions for some common errors.
			
			Added default pan, tilt and zoom to the preferences and the pict to movie
			window.

28 Feb 96	Fixed file name length problems.

			Switched to different path name code from "More Files."

27 Feb 96	Finished implementing drop mode.

			Force cursor to the arrow before displaying an error alert.

27 Feb 96	Added preferences dialog with default settings and a check box for
			existing file replacement. Also added tile and movie file suffix
			editing.
			
			Changed about box pict to include both people.
			
			Moved movie creation start up code from the window to the application in prep
			for doing drop mode.
			
			Fixed drop mode menu item. (Still need to do drop mode!)
			
			Change nature of progress event handling to allow up to three events
			to be processed at one call of the progress proc. Also knocked down
			the sleep time to zero.
			
			Implemented preferences and preferences i/o.
			
			Movie creation code now can come up with unique file names to avoid
			replacing existing files.
			
			Implemented the Make Default button.

4 Feb 96	Added text to the right of the compression settings button to display
			the current compression settings.
			
			Removed the create all button. Added a Make Default button. Need to implement
			its functionality.

3 Feb 96	Implemented compression settings UI. Window now named to the name of the
			source PICT file.
			
			Created 68K project.
			
			Tested using several large PICTS.

29 Jan 96	Created this application. Created self contained code as much as possible
			to make it more practical to release the source code of this app should we
			decide to do so.


To Do:
======

-	Implement warnings if height is not mod 96 == 0 with recommended sizes.

-	Testing.

-	Read me.