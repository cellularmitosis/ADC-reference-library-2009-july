

#include <QuickDraw.h>
#include "BigEasyTextish.h"
#include "IE PrintUtilities.h"



void PrintPlural(long x, StringPtr zero,StringPtr s1,StringPtr pluralizer, StringPtr s2)
	{
	if(x)
		DrawNum(x);
	else
		{
		if(zero)
			DrawString(zero);
		else
			DrawString("\pNo");
		}
	DrawChar(' ');
	DrawString(s1);
	if(x != 1 && x != -1)
		{
		if(pluralizer)
			DrawString(pluralizer);
		else
			DrawChar('s');
		}
	if(s2)
		DrawString(s2);
	}

